
CORE_IMAGE_EXTRA_INSTALL += "aeld-assignments"